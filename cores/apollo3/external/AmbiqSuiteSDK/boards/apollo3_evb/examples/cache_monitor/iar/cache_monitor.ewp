# IAR project cache_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; APS6404L; AM_PART_APOLLO3; AM_PRINTF_BUFSIZE=256
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\utils; ..\..\..\..\..; ..\src; ..\..\..\bsp; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cache_monitor.bin
  ILINK.IlinkOutputFile: cache_monitor.out
  ILINK.IlinkIcfFile: cache_monitor.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a; ..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; APS6404L; AM_PART_APOLLO3; AM_PRINTF_BUFSIZE=256
  group (top)
    ../../../../../third_party/prime_mpi/src/: prime_mpi.c
    ../src/: cache_monitor.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../devices/: am_devices_mspi_psram_aps6404l.c
    ./: startup_iar.c
